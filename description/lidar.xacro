Commit message: Update lidar.xacro

File: description/lidar.xacro (robot description, xacro)
@@ -23,4 +23,5 @@
     </link>
     <gazebo reference="laser_frame">
+        <material>Gazebo/Red</material>
         <sensor name="laser" type="ray">
             <pose> 0 0 0 0 0 0 </pose>
